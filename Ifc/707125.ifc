Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Ostnor
Time: 2008-09-22T09:53:00
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: Mora Rexx 707125, 707125:Mora Rexx 707125:Mora Rexx 707125:128617
In: Level 1
PSet_Revit_Dimensions - Counter Height: 900 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 33
PSet_Revit_Type_Identity Data - URL: www.moraarmatur.com; RSK: 831 81 89; NRF: 429 02 28; Model: 707125; Manufacturer: Mora Armatur AB; LVI: 6261175; Family: Mora Rexx; Description: Mora Rexx K7 Kitchen Mixer with on/off valve for dishwashing machine Chrome, also available as Chrome/Black and Stainless look
